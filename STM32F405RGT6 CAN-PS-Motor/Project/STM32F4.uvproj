# Keil uVision project STM32F4.uvproj, settings and files
target STM32F4 (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries;..\Mylib;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c
  group Mylib
    ../Mylib/: delay.c can1.c led.c ps2.c sys.c
  group Libraries
    ../Libraries/: startup_stm32f4xx.s misc.c stm32f4xx_can.c stm32f4xx_gpio.c system_stm32f4xx.c stm32f4xx_rcc.c
